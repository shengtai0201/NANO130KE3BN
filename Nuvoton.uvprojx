# Keil uVision project Nuvoton.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: NANO130KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Nuvoton
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c test.c default.c nano100_timer.c nano100_uart.c lcd1602.c nano100_adc.c thermistor.c nano100_pwm.c nano100_i2c.c bh1750.c button.c esp8266.c keypad.c mqtt.c step_motor.c nano100_spi0.c nrf24l01.c cc2541.c
  group SleepApnea
    ./: breathe.c wave.c
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, Data Exchange:JSON:Jansson 2.7.0, Device:Driver:ADC 3.02.002, Device:Driver:CLK 3.02.002, Device:Driver:GPIO 3.02.002, Device:Driver:PWM 3.02.002, Device:Driver:SPI 3.02.002, Device:Driver:SYS 3.02.002, Device:Driver:Timer 3.02.002, Device:Driver:UART 3.02.002, Device:Startup 3.02.002
