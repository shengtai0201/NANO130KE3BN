# Keil uVision project default.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: NANO130KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: default
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c uart.c default.c lcd1602.c
software components: CMSIS:CORE 5.0.2, Device:Driver:CLK 3.02.002, Device:Driver:GPIO 3.02.002, Device:Driver:SYS 3.02.002, Device:Driver:UART 3.02.002, Device:Startup 3.02.002
